# Keil uVision project VROneCmdApp.uvprojx, settings and files
target VoiceRecognition (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: I9160 Nuvoton
  pack: Nuvoton.NuVoice_ISD_DFP.1.0.0
  cpu: IRAM(0x20000000,0x3000) IROM(0x00000000,0x24400) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: VoiceRecognition +hex
  BeforeMake: .\PreBuild.bat
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: __ISD9100__
  c include: .;..\..\Library\Device\Nuvoton\ISD9100\Include;..\..\Library\Framework\inc;..\..\Library\IO\inc;..\..\Library\Audio\inc;..\..\Library\StdDriver\inc;..\..\Library\Storage\inc;..\..\Library\CMSIS\Include;..\;..\..\Library\Device\Nuvoton\ISD9100\Include;..\..\Library\StdDriver\inc;..\Keil;..\..\OneCommand;..\VROneCmdApp
  asm define: __ISD9100__
  memory RVCT4: ROM 0x0 size 0x24400
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --pd="-DSRAM_SIZE=0x3000" --pd="-DROM_SIZE=0x24400" --map --datacompressor=off --info=inline --entry Reset_Handler --remove
  group Source
    ../: ReadMe.txt Readme_FileInfo.txt main.c AppFunctions.c AppCallback.c InputKeyActions.c InterruptHandler.c Powerdown.c Preload.c
  group Include
    ../: App.h ConfigApp.h ConfigSysClk.h ConfigIO.h ConfigIP.h ConfigUltraIO.h
  group MicGetApp
    ../MicGetApp/: MicGetApp.c MicGetApp.h
  group MD4App
    ../MD4App/: MD4App.c MD4App.h
  group VROneCmdApp
    ../VROneCmdApp/: VROneCmdApp.c VROneCmdApp.h
  group CMSIS
    ../../Library/Device/Nuvoton/ISD9100/Source/: system_ISD9100.c
    ../../Library/Device/Nuvoton/ISD9100/Source/ARM/: startup_ISD9100.s
  group Framework
    ../../Library/Framework/src/: SysClk.c AudioMixer.c AudioRom.c ConfigIO.c BufCtrl.c MicSpk.c PdmaCtrl.c Playback.c SPIFlashUtil.c VolumeCtrl.c Record.c
  group Storage
    ../../Library/Storage/src/: SPIFlash.c
  group IO
    ../../Library/IO/src/: Keypad.c
  group Driver
    ../../Library/StdDriver/src/: acmp.c adc.c biq.c bod.c capsense.c clk.c CRC.c dpwm.c fmc.c gpio.c i2c.c i2s.c pdma.c pwm.c rtc.c spi.c sys.c talarm.c timer.c uart.c wdt.c retarget.c
  group Library
    ../../Library/Audio/arm/: MD4_Keil.lib
    ../VROneCmdApp/: libCSpotterSDK_16k_24d_ISD9xxC_arm-cm0_V6.4.4_b20180328.lib
  group AudioRes
    ../AudioRes/: AudioRes.uid
software components: CMSIS:CORE 5.1.2
